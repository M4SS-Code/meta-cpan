require carp-perl-${PV}.inc

inherit native
