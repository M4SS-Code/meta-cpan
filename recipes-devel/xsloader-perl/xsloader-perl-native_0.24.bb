require xsloader-perl-${PV}.inc

inherit native
