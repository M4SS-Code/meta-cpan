require io-perl-${PV}.inc

inherit native
