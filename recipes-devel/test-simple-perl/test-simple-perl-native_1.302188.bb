require test-simple-perl-${PV}.inc

inherit native
