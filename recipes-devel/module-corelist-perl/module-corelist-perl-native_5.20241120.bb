require module-corelist-perl-${PV}.inc

SRC_URI += "file://0001-remove-exe-files.patch"

inherit native
