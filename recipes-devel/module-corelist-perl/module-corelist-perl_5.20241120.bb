require module-corelist-perl-${PV}.inc
