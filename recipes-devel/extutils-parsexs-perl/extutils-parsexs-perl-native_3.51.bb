require extutils-parsexs-perl-${PV}.inc

inherit native
